# Keil uVision project ADC.uvprojx, settings and files
target FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\App;.\LIB\CMSISV1.2.0\Core\CM3;.\LIB\CMSISV1.2.0\Core\CM3\startup\arm;.\LIB\ALIENTEK_MiniSTM32_REVB0_HardWare_V1.1;.\LIB\STM32F10x_StdPeriph_DriverV3.1.1\src;.\LIB\STM32F10x_StdPeriph_DriverV3.1.1\inc;.\SYSTEM\sys;.\SYSTEM\delay;..\开关电源程序;.\Hardware\LCD;.\SYSTEM\usart;.\SYSTEM\eval
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./LIB/CMSISV1.2.0/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./LIB/CMSISV1.2.0/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group APP
    ./App/: main.c pid.c GUI.c cpwm.c key.c adc.c caiyang.c dac.c usart2.c common.c
  group LIB_V3_1_1
    ./LIB/STM32F10x_StdPeriph_DriverV3.1.1/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./App/: stm32f10x_it.c
  group Hardware
    ./Hardware/LCD/: lcd.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/eval/: eval.c
software components: CMSIS:CORE 5.0.0
